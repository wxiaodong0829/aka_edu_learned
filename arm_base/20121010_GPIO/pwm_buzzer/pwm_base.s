	AREA PWM_BASE,CODE,READONLY
	CODE32
	ENTRY
	
START
	LDR R0,=0XE02000A0		;GPD0CON  只设置自己关心的，不关心的不要动
	LDR R1,[R0]
	BIC R1,R1,#4	;		;AND R1,R1,#0XFFFFFFF0
	ORR R1,R1,#0X1
	
	STR R1,[R0]
	
	LDR R2,=0XE02000A4
LOOP
	MOV R3,#0X1
	STR R3,[R2]
	
	BL DELAY
	
	MOV R3,#0X0
	STR R3,[R2]
	
	BL DELAY
	
	B LOOP
	
DELAY
	LDR R4,=0XFFFFFFF
LOOP_DEL
	SUBS R4,R4,#1
	BNE LOOP_DEL
	MOV PC,LR
	
	END